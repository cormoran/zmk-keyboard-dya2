## boards/shields/dya2/Kconfig.shield
```kconfig
config SHIELD_DYA2_LEFT
   def_bool $(shields_list_contains,dya2_left)

config SHIELD_DYA2_RIGHT
   def_bool $(shields_list_contains,dya2_right)
```
